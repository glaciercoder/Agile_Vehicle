# Keil uVision project control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE\Motor;.\STM32F10x_FWLib\src;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\exti;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\TIMER;.\HARDWARE\CAN;.\HARDWARE\STEPPER;.\HARDWARE\ADC;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group HARDWARE
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/STEPPER/: stepper.c
    ./HARDWARE/Motor/: motor.c
    ./HARDWARE/ADC/: adc.c
    ./HARDWARE/: my_lib.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s core_cm3.h
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group FW_LIB
    ./STM32F10x_FWLib/src/: stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_exti.c stm32f10x_crc.c stm32f10x_dbgmcu.c misc.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dma.c
  group SYS
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/exti/: exti.c
